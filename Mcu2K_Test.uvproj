# Keil uVision project Mcu2K_Test.uvproj, settings and files
target ABS_NewProject_XC2K (166/167)
  device: XC2365B-40F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE03FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC4FFFF) CLOCK(80000000) MOD167 MODV2
  output: Mcu2K_Test +hex
  group Hw_Driver
    ./: START_V3.A66
    ./Hw_Driver/: adc.c hw.c rtc.c scs.c ssc.c timer.c trap.c Lib_Hw_Driver_Version.c xc2k_can.c ccu2_ccu6.c
    ./src/: tle9180d_31qk.c
  group EOL_Diag
    ./EOL_Diag/: can_test.c Lib_EOL_Diag_Version.c
  group DTC_Diag
    ./DTC_Diag/: diag_hw.c dtc_man.c mcu1_imp.c task_man.c eeprom.c Lib_DTC_Diag_Version.c
  group CalTool
    ./CalTool/: gpara.c gvar.c
  group DTC_Diag_MCU2
    ./DTC_Diag/mcu2_prot/: dtc_man_mcu2.c dtc_table.c mcu2_imp.c prot_imp.c ypara.c
  group CAN_Driver
    ./CAN_Driver/: hican.c
  group XCP
    ./xcp/: _xcp_appl.c xcp_par.c XcpBasic.c xcp_can.c
  group App_Main
    ./src/: main.c ctrl.c main_task.c resolver_ad2s.c pwm.c motor_bldc.c motor_pmsm.c svpwm.c filters.c sin_data.c ctrl_if.c sent_decode.c pid.c
  group EBS_Ctrl_Logic
    ./EBS_Ctrl_Logic/: MotorCtrlSet.c MotorDrive.c ebooster_ctrl.c Filters_EbsSensors.c
    ./src/: aut_drv.c
