# Keil uVision project Eol_Diag.uvproj, settings and files
target Eol Diag (166/167)
  device: XC2365-48F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC5FFFF) CLOCK(20000000) MOD167 MODV2
  output: Eol_Diag (library)
  group Source Group
    ../objs/: can_test.obj kline_test.obj xc2k_can.obj xc2k_kline.obj
