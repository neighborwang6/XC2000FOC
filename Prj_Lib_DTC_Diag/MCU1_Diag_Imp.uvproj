# Keil uVision project MCU1_Diag_Imp.uvproj, settings and files
target MCU1_Diag_Imp (166/167)
  device: XC2365-48F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC5FFFF) CLOCK(20000000) MOD167 MODV2
  output: MCU1_Diag_Imp (library)
  group Source Group
    ../objs/: mcu1_imp.obj diag_hw.obj dtc_man.obj task_man.obj eeprom.obj dtc_table.obj dtc_man_mcu2.obj mcu2_imp.obj ypara.obj prot_imp.obj suart.obj bleeding.obj Lib_DTC_Diag_Version.obj
