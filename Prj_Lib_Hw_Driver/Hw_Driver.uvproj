# Keil uVision project Hw_Driver.uvproj, settings and files
target Hw_Driver (166/167)
  device: XC2365-48F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC5FFFF) CLOCK(20000000) MOD167 MODV2
  output: Hw_Driver (library)
  group Source Group
    ../objs/: valve.obj adc.obj ccu6.obj hcu.obj hw.obj Lib_Hw_Driver_Version.obj motor.obj rtc.obj scs.obj ssc.obj timer.obj tle6212.obj trap.obj uart.obj quick_dbg.obj
