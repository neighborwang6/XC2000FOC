# Keil uVision project CalTool.uvproj, settings and files
target CalTool for ABS ECU V2 (166/167)
  device: XC2365-48F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC5FFFF) CLOCK(20000000) MOD167 MODV2
  output: CalTool (library)
  group Source Group
    ../objs/: gvar.obj gpara.obj
